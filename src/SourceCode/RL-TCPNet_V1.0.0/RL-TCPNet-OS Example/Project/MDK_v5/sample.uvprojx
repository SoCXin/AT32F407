# Keil uVision project sample.uvprojx, settings and files
target sample (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AT32F407VGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Telnet
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F407VGT7,LIBRARY_VERSION,AT_START_F407_V1_0
  c include: ..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\AT32_Board;..\..\Project;..\User\inc;..\..\RL-ARM\Config;..\..\RL-ARM\RL-RTX\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../User/src/: main.c at32f4xx_it.c eth_config.c
    ../../RL-ARM/Config/: Net_Config.c
  group BSP
    ../../AT32_Board/: at32_board.c
  group RTX
    ../../RL-ARM/Config/: RTX_Conf_CM.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f407vgt7.s
  group AT32Periph
    ../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_dma.c at32f4xx_eth.c at32f4xx_gpio.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_usart.c misc.c
  group RL-TCPNet/Lib
    ../../RL-ARM/RL-TCPnet/: TCP_CM3.lib
  group README
    ../: readme.txt
